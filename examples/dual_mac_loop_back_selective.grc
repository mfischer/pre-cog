<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>parameter</key>
<param><key>id</key><value>args</value></param>
<param><key>label</key><value>args</value></param>
<param><key>value</key><value></value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>selective_arq_mac</key>
<param><key>id</key><value>selective_arq_mac_0</value></param>
<param><key>addr</key><value>85</value></param>
<param><key>tx_wsz</key><value>120</value></param>
<param><key>rx_wsz</key><value>42</value></param>
</block>
<block>
<key>selective_arq_mac</key>
<param><key>id</key><value>selective_arq_mac_1</value></param>
<param><key>addr</key><value>86</value></param>
<param><key>tx_wsz</key><value>120</value></param>
<param><key>rx_wsz</key><value>42</value></param>
</block>
<block>
<key>extras_blob_to_socket</key>
<param><key>id</key><value>extras_blob_to_socket_0_0</value></param>
<param><key>proto</key><value>UDP</value></param>
<param><key>addr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>12346</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>no_arq_port</value></param>
<param><key>value</key><value>12345</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>arq_port</value></param>
<param><key>value</key><value>12346</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>virtual_channel_formatter</key>
<param><key>id</key><value>virtual_channel_formatter_0</value></param>
<param><key>channel</key><value>86</value></param>
<param><key>arq</key><value>1</value></param>
</block>
<block>
<key>heart_beat</key>
<param><key>id</key><value>heart_beat_0_0</value></param>
<param><key>period</key><value>2</value></param>
<param><key>key</key><value>W</value></param>
<param><key>value</key><value>this is a test beacon from mac0\n</value></param>
</block>
<block>
<key>virtual_channel_formatter</key>
<param><key>id</key><value>virtual_channel_formatter_0_0</value></param>
<param><key>channel</key><value>85</value></param>
<param><key>arq</key><value>1</value></param>
</block>
<block>
<key>heart_beat</key>
<param><key>id</key><value>heart_beat_0_0_0</value></param>
<param><key>period</key><value>2</value></param>
<param><key>key</key><value>W</value></param>
<param><key>value</key><value>this is a test beacon from mac1\n</value></param>
</block>
<block>
<key>extras_blob_to_socket</key>
<param><key>id</key><value>extras_blob_to_socket_0</value></param>
<param><key>proto</key><value>UDP</value></param>
<param><key>addr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>12345</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>dual_mac_loop_back</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<connection><source_block_id>selective_arq_mac_0</source_block_id><sink_block_id>selective_arq_mac_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>selective_arq_mac_0</source_block_id><sink_block_id>extras_blob_to_socket_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>selective_arq_mac_1</source_block_id><sink_block_id>extras_blob_to_socket_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_channel_formatter_0_0</source_block_id><sink_block_id>selective_arq_mac_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>selective_arq_mac_1</source_block_id><sink_block_id>selective_arq_mac_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_channel_formatter_0</source_block_id><sink_block_id>selective_arq_mac_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>heart_beat_0_0_0</source_block_id><sink_block_id>virtual_channel_formatter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>heart_beat_0_0</source_block_id><sink_block_id>virtual_channel_formatter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
